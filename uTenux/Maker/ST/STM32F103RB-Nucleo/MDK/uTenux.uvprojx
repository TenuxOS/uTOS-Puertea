# Keil uVision project uTenux.uvprojx, settings and files
target STM32F103RB-Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uTenux +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,CPU_ARMV7_M
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\uTOS\Include;..\..\..\..\uTOS\Source;..\..\..\..\uTOS\Source\sysdepend\armv7_m;..\..\..\..\uTOS\Source\sysdepend\armv7_m\acc;..\Config
  asm misc: --cpreproc --cpreproc_opts=-D,CPU_ARMV7_M,-D,__ASM_ARM
  asm include: ..\..\Libraries\\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\uTOS\Include;..\..\..\..\uTOS\Source;..\..\..\..\uTOS\Source\sysdepend\armv7_m;..\..\..\..\uTOS\Source\sysdepend\armv7_m\acc;..\Config
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\uTenux-flash.sct
  link misc: --entry=reset_handler  --datacompressor=off
  group App
    ../App/: usermain.c
  group Config
    ../Config/: tk_config_depend.h tm_bsp.c tm_monitor.c
  group Startup
    ./: startup.S
  group uTOS
    ../../../../uTOS/Source/: knl_bit.c knl_tck.c knl_tsk.c knl_mem.c tk_almimpl.c tk_cycimpl.c tk_flgimpl.c tk_hokimpl.c tk_hokwrap.S tk_intimpl.c tk_mbfimpl.c tk_mbximpl.c tk_mpfimpl.c tk_mplimpl.c tk_mtximpl.c tk_porimpl.c tk_semimpl.c tk_sysimpl.c tk_timimpl.c tk_tskimpl.c
    ../../../../uTOS/Source/sysdepend/armv7_m/: knl_cpu.c knl_ctx.c knl_pow.c knl_tmr.c
    ../../../../uTOS/Source/sysdepend/armv7_m/acc/: knl_dsp.S knl_hok.S knl_int.S
software components: CMSIS:CORE 5.0.1
